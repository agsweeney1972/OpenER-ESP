## sdkconfig.defaults
```kconfig
CONFIG_ETH_ENABLED=y
CONFIG_ETH_USE_ESP32_EMAC=y
CONFIG_ETH_PHY_INTERFACE_MII=y
CONFIG_ETH_PHY_ADDR=0
CONFIG_LWIP_SO_RCVBUF=y
```
